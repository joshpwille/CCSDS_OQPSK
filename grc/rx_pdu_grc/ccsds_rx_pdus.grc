options:
  parameters:
    generate_options: qt_gui
    id: ccsds_rx_pdus
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: I_RS
  id: variable
  parameters:
    value: '5'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/dogg/Downloads/tm_stagin_grc/qpsk/data/rx_pdus/viterbi_out.bin
    repeat: 'True'
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "# add near the other imports\nfrom gnuradio import gr, pdu\nimport pmt\n\nclass pdu_drop_head_asm(gr.basic_block):\n    def __init__(self, n_drop=4):\n        gr.basic_block.__init__(self,\n            name=\"pdu_drop_head_asm\",\n            in_sig=None, out_sig=None)\n        self.message_port_register_in(pmt.intern('in'))\n        self.message_port_register_out(pmt.intern('out'))\n        self.set_msg_handler(pmt.intern('in'), self.handle)\n\n        self.n_drop = n_drop\n\n    def handle(self, msg):\n        meta = pmt.to_python(pmt.car(msg)) or {}\n        vec  = pmt.cdr(msg)\n        b    = bytearray(pmt.u8vector_elements(vec))\n        if len(b) >= self.n_drop:\n            b = b[self.n_drop:]           # strip 4-byte ASM\n        outp = pmt.cons(pmt.to_pmt(meta), pmt.init_u8vector(len(b), b))\n        self.message_port_pub(pmt.intern('out'), outp)\n\n"
    n_drop: '4'
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: satellites_ccsds_descrambler_0
  id: satellites_ccsds_descrambler
  parameters: {}
  states: {}
- name: satellites_decode_rs_ccsds_0
  id: satellites_decode_rs_ccsds
  parameters:
    basis: 'False'
    interleave: I_RS
  states: {}

connections:
- [blocks_file_source_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [epy_block_0, out, satellites_decode_rs_ccsds_0, in]
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_file_sink_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_0, in]
- [satellites_ccsds_descrambler_0, out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [satellites_decode_rs_ccsds_0, out, satellites_ccsds_descrambler_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.7.0
