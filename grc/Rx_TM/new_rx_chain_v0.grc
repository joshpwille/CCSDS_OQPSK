options:
  parameters:
    generate_options: qt_gui
    id: new_rx_chain_v0
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: ASM_BYTES
  id: variable
  parameters:
    comment: ASM = 0x1A CF FC 1D (4 bytes)
    value: len(ASM_MARKER)
  states: {}
- name: ASM_MARKER
  id: variable
  parameters:
    value: (0x1A, 0xCF, 0xFC, 0x1D)
  states: {}
- name: BYTES_PER_FRAME
  id: variable
  parameters:
    value: '1115'
  states: {}
- name: CADU_RS_ASM_BYTES
  id: variable
  parameters:
    value: RS_BYTES + ASM_BYTES
  states: {}
- name: I_RS
  id: variable
  parameters:
    comment: RS interleave depth (because 223 × 5 = 1115)
    value: '5'
  states: {}
- name: RSYM
  id: variable
  parameters:
    value: samp_rate/sps
  states: {}
- name: RS_BYTES
  id: variable
  parameters:
    value: 255 * I_RS
  states: {}
- name: RS_info_bytes
  id: variable
  parameters:
    value: '223'
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: costas_bw
  id: variable
  parameters:
    value: '2e-3'
  states: {}
- name: costas_order
  id: variable
  parameters:
    comment: 4 b/c qpsk
    value: '4'
  states: {}
- name: cuttoff_freq
  id: variable
  parameters:
    value: 0.6 * (1 + alpha) * RSYM
  states: {}
- name: filter_size
  id: variable
  parameters:
    value: '32'
  states: {}
- name: loop_bw
  id: variable_qtgui_range
  parameters:
    start: '0.002'
    step: '0.001'
    stop: '0.012'
    value: '0.005'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1.0, samp_rate, RSYM, alpha, span_symbols*sps*filter_size)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: soft_flip
  id: variable
  parameters:
    value: '1'
  states: {}
- name: span_symbols
  id: variable
  parameters:
    value: '8'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: trans_width
  id: variable
  parameters:
    value: 0.005 * samp_rate
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(sps//2)
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/dogg/Downloads/tm_stagin_grc/qpsk/data/Rx_data/unwrapped.bin
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/dogg/Downloads/tm_stagin_grc/qpsk/data/Rx_data/ppcs_out.cfile
    type: complex
  states: {}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: /home/dogg/Downloads/tm_stagin_grc/qpsk/data/Rx_data/source_check.cfile
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/dogg/Downloads/tm_stagin_grc/qpsk/data/Rx_data/tx_out.cfile
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: soft_flip
    type: float
  states: {}
- name: digital_constellation_soft_decoder_cf_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: qpsk
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: costas_order
    w: costas_bw
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: filter_size
    init_phase: '16'
    loop_bw: loop_bw
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cuttoff_freq
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: trans_width
    win: window.WIN_HAMMING
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: satellites_ccsds_concatenated_deframer_0
  id: satellites_ccsds_concatenated_deframer
  parameters:
    convolutional: '"CCSDS"'
    frame_size: '223'
    precoding: None
    rs_basis: '"dual"'
    rs_interleaving: I_RS
    scrambler: '"CCSDS"'
    threshold: '2'
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_float_0, '1', blocks_delay_0, '0']
- [blocks_delay_0, '0', blocks_float_to_complex_0, '1']
- [blocks_file_source_0, '0', blocks_file_sink_1_0, '0']
- [blocks_file_source_0, '0', low_pass_filter_0, '0']
- [blocks_float_to_complex_0, '0', digital_costas_loop_cc_0, '0']
- [blocks_multiply_const_vxx_0, '0', satellites_ccsds_concatenated_deframer_0, '0']
- [digital_constellation_soft_decoder_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_soft_decoder_cf_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', blocks_complex_to_float_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', blocks_file_sink_1, '0']
- [low_pass_filter_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_file_sink_0, '0']
- [satellites_ccsds_concatenated_deframer_0, out, pdu_pdu_to_tagged_stream_0_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.7.0
